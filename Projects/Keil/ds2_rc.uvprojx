# Keil uVision project ds2_rc.uvprojx, settings and files
target Develop (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC11U68JBD64 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x0800) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: ds2_rc +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0PLUS, __CC_ARM, NO_BOARD_LIB
  c include: C:\Keil_v5\ARM\ARMCC\include;..\..\Code\APP;..\..\Code\BSP;..\..\Code\ThirdParty\CMSIS\Include;..\..\Code\ThirdParty\CMSIS\RTOS2\Include;..\..\Code\ThirdParty\CMSIS\RTOS2\RTX\Config;..\..\Code\ThirdParty\CMSIS\RTOS2\RTX\Include;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_11u6x;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_11u6x\config_11U6X;..\..\Code\ThirdParty\lpc_core\lpc_chip\chip_common;..\..\Code\ThirdParty\RTX;..\..\Code\Utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x800
  group APP
    ../../Code/APP/: app.c buttons.c debug.c indication.c
  group APP/CLI
    ../../Code/APP/cli/: cli.c cli_app.c cli_cmd.c
  group APP/Display
    ../../Code/APP/display/: display.c display_menu.c display_popup.c fonts.c ssd1306.c
  group APP/Radio
    ../../Code/APP/radio/: nrf24l01.c radio.c
  group APP/Sensors
    ../../Code/APP/sensors/: filters.c joystick.c sensors.c
  group BSP
    ../../Code/BSP/: bsp.c faults.c
  group BSP/Device
    ../../Code/BSP/Device/: sysinit.c keil_startup_lpc11u6x.s
  group BSP/Periph
    ../../Code/BSP/Periph/: adc.c gpio.c ssp.c uart.c wdt.c
  group ThirdParty/CMSIS/RTOS2/RTX
    ../../Code/ThirdParty/CMSIS/RTOS2/RTX/Config/: RTX_Config.c RTX_Config.h
    ../../Code/ThirdParty/CMSIS/RTOS2/RTX/Library/: RTX_CM0.lib
    ../../Code/ThirdParty/CMSIS/RTOS2/RTX/Source/: rtx_lib.c
  group ThirdParty/lpc_chip_11u6x
    ../../Code/ThirdParty/lpc_core/lpc_chip/chip_11u6x/: adc_11u6x.c chip_11u6x.c clock_11u6x.c crc_11u6x.c dma_11u6x.c gpio_11u6x.c gpiogroup_11u6x.c i2c_11u6x.c i2cm_11u6x.c iocon_11u6x.c pinint_11u6x.c pmu_11u6x.c romdiv_11u6x.c rtc_11u6x.c sct_11u6x.c syscon_11u6x.c sysinit_11u6x.c ssp_11u6x.c stopwatch_11u6.c timer_11u6x.c uart_0_11u6x.c uart_n_11u6x.c wwdt_11u6x.c
  group ThirdParty/lpc_chip_common
    ../../Code/ThirdParty/lpc_core/lpc_chip/chip_common/: eeprom.c flash.c ring_buffer.c
  group Utils
    ../../Code/Utils/: common.h
